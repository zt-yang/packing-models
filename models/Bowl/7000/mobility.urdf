Commit message: pack bowl

File: models/Bowl/7000/mobility.urdf (robot description, URDF)
Before this commit: robot Bowl_8e840ba109f252534c6955b188e290e0_M, 2 links, 1 joints
Links:
- link link_0: mass None -> 0.2
